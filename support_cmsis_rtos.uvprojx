# Keil uVision project support_cmsis_rtos.uvprojx, settings and files
target Cortex-M0 (6160000::V6.16::ARMCLANG)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: support_cmsis_rtos_m0 (library)
  AfterMake: .keil\copy.bat mcuf_m0.lib
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c misc: -fexceptions -frtti
  c include: .\src\main;.\src\resources
  asm include: ..\framework
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group main
    ./src/main/: support_cmsisrtos.h
  group main/cmsisrtos
    ./src/main/cmsisrtos/: package-info.h CmsisRtosKernel.cpp CmsisRtosKernel.h CmsisRtosThread.cpp CmsisRtosThread.h CmsisRtosTimer.cpp CmsisRtosTimer.h
target Cortex-M0PLUS (6160000::V6.16::ARMCLANG)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: support_cmsis_rtos_m0plus (library)
  AfterMake: .keil\copy.bat mcuf_m0plus.lib
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\src\main;.\src\resources
  asm include: ..\framework
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
target Cortex-M3 (6160000::V6.16::ARMCLANG)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: support_cmsis_rtos_m3 (library)
  AfterMake: .keil\copy.bat mcuf_m3.lib
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\src\main;.\src\resources
  asm include: ..\framework
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
target Cortex-M4 (6160000::V6.16::ARMCLANG)
  device: ARMCM4 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") CLOCK(12000000) ESEL ELITTLE
  output: support_cmsis_rtos_m4 (library)
  AfterMake: .keil\copy.bat mcuf_m4.lib
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\src\main;.\src\resources;.\ref\mcuf\src\main
  asm include: ..\framework
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
target Cortex-M4F (6160000::V6.16::ARMCLANG)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: support_cmsis_rtos_m4f (library)
  AfterMake: .keil\copy.bat mcuf_m4f.lib
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\src\main;.\src\resources
  asm include: ..\framework
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
target Cortex-M7 (6160000::V6.16::ARMCLANG)
  device: ARMCM7 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M7") CLOCK(12000000) ESEL ELITTLE
  output: support_cmsis_rtos_m7 (library)
  AfterMake: .keil\copy.bat mcuf_m7.lib
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\src\main;.\src\resources
  asm include: ..\framework
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
software components: CMSIS:CORE 5.5.0, CMSIS:RTOS2:Keil RTX5 5.5.3
